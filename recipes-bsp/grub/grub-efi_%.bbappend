#This was added to allow the native sdk be generated
EXTRA_OECONF += " --disable-werror"