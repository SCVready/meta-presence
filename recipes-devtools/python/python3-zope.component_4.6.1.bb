LICENSE = "MIT"

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=78ccb3640dc841e1baecb3e27a6966b2"

SRC_URI[md5sum] = "5bfb8965cfa0ad4c311dedd297496ea4"
SRC_URI[sha256sum] = "d9c7c27673d787faff8a83797ce34d6ebcae26a370e25bddb465ac2182766aca"

inherit pypi setuptools3

PYPI_PACKAGE = "zope.component"
