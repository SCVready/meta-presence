LICENSE="CLOSED"
LIC_FILES_CHKSUM=""

SRC_URI[md5sum] = "7e583285b1fb8a76305d6d68f4ccc14e"
SRC_URI[sha256sum] = "a7bb0f2cf3a3fd1ab2732cb49eba4252c2af4240442415b4abce3b87022a8f50"

inherit pypi setuptools3

PYPI_PACKAGE = "funcsigs"
