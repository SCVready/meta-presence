
LICENSE = "MIT"

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=78ccb3640dc841e1baecb3e27a6966b2"

SRC_URI[md5sum] = "53bccb21aab8894a68f40ee2f202465d"
SRC_URI[sha256sum] = "40e4c42bd27ed3c11b2c983fecfb03356fae1209de10686d03c02c8696a1d90e"

inherit pypi setuptools3

PYPI_PACKAGE = "zope.interface"
