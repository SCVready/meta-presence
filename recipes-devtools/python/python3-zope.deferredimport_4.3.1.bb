LICENSE="CLOSED"
LIC_FILES_CHKSUM=""

SRC_URI[md5sum] = "9fb87ae9f3467411e8ec7844b4792926"
SRC_URI[sha256sum] = "57b2345e7b5eef47efcd4f634ff16c93e4265de3dcf325afc7315ade48d909e1"

inherit pypi setuptools3

PYPI_PACKAGE = "zope.deferredimport"
