LICENSE = "MIT"

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=78ccb3640dc841e1baecb3e27a6966b2"

SRC_URI[md5sum] = "88354666d48df31c75d20e52afd2d0fe"
SRC_URI[sha256sum] = "29d07681a78042cdd15b268ae9decffed9ace68a53eebeb61d65ae931d158841"

inherit pypi setuptools3

PYPI_PACKAGE = "zope.hookable"
