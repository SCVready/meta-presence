LICENSE = "MIT"

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=78ccb3640dc841e1baecb3e27a6966b2"

SRC_URI[md5sum] = "6915a92473e2658b3954f8490938455c"
SRC_URI[sha256sum] = "0d453338f04bacf91bbfba545d8bcdf529aa829e67b705eac8c1a7fdce66e2df"

inherit pypi setuptools3

PYPI_PACKAGE = "zope.deprecation"
