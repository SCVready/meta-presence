LICENSE="CLOSED"
LIC_FILES_CHKSUM=""

SRC_URI[md5sum] = "c829980738b8271b0179ffd0c41187b0"
SRC_URI[sha256sum] = "81b8cbe1519cdb79bed04910dd6fa4e181faf8c88dff1e1b987b5f7ab23a5b1a"

inherit pypi setuptools3

PYPI_PACKAGE = "pyRFC3339"
