LICENSE="CLOSED"
LIC_FILES_CHKSUM=""

SRC_URI[md5sum] = "5671731166253bc2407454fac9032089"
SRC_URI[sha256sum] = "a5a182eb499665d99e7ec54bb3fe389f9cbc483d429c9651f20384ba29564269"

inherit pypi setuptools3

PYPI_PACKAGE = "josepy"
