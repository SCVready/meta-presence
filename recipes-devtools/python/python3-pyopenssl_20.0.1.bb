LICENSE="CLOSED"
LIC_FILES_CHKSUM=""

SRC_URI[md5sum] = "40f81b5faf059e89ab4377ec5554bd5e"
SRC_URI[sha256sum] = "4c231c759543ba02560fcd2480c48dcec4dae34c9da7d3747c508227e0624b51"

inherit pypi setuptools3

PYPI_PACKAGE = "pyOpenSSL"
