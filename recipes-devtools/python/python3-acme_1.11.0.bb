LICENSE="CLOSED"
LIC_FILES_CHKSUM=""

SRC_URI[md5sum] = "2ea41be3043f0353587274ffbf01032f"
SRC_URI[sha256sum] = "092eb09a074a935da4c10f66cb8634ffb2cc2d2cc1035d2998d608996efab924"

inherit pypi setuptools3

PYPI_PACKAGE = "acme"
