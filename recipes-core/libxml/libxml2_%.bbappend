RDEPENDS_${PN}_append = " icu"
DEPENDS_append = " icu"
